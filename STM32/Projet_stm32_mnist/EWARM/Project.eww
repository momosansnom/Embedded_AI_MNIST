<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Projet_stm32_mnist.ewp</path>
  </project>
  <batchBuild />
</workspace>
